# Keil uVision project AT32F413RCT7_WorkBench_1.uvprojx, settings and files
target AT32F413RCT7_WorkBench_1 (6230000::V6.23::ARMCLANG)
  device: -AT32F413RCT7 ArteryTek
  pack: ArteryTek.AT32F413_DFP.2.1.7
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F413RCT7_WorkBench_1 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=3
  c define: AT32F413RCT7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c at32f413_wk_config.c at32f413_int.c wk_system.c
  group firmware
    ../../libraries/drivers/src/: at32f413_crm.c at32f413_gpio.c at32f413_usart.c at32f413_pwc.c at32f413_adc.c at32f413_flash.c at32f413_misc.c at32f413_debug.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f413.c
    ./: startup_at32f413.s
